# Keil uVision project Gimbal_Control.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ..\File\API;..\File\BSP;..\File\RM_Types;..\File\STM32_LIB\CMSIS;..\File\STM32_LIB\FWLIB;..\File\TASK;..\File\USER
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group RM_Types
    ../File/RM_Types/: ParamConfig.h rm_communicate_types.h rm_os_types.h rm_pid_types.h rm_rc_types.h rm_redefine_types.h rm_rs_types.h rm_scanner_types.h
  group USER
    ../File/USER/: main.c os.c stm32f4xx_it.c bsp_init.c global_declare.c system_stm32f4xx.c
  group TASK
    ../File/TASK/: system_monitor_task.c imu_update_task.c gimbal_task.c
  group API
    ../File/API/: verify.c can_protocol.c rm_algorithm.c bmi088_driver.c chassis_protocol.c general_math.c
  group BSP
    ../File/BSP/: can.c delay.c nvic.c spi.c tim.c usart.c systick.c gpio.c
  group CMSIS
    ../File/STM32_LIB/CMSIS/: startup_stm32f40_41xxx.s
  group FWLIB
    ../File/STM32_LIB/FWLIB/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
